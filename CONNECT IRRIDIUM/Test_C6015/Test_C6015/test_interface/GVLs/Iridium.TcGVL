{attribute 'qualified_only'}
VAR_GLOBAL
	x : ARRAY [0..9] OF REAL;
	input  AT %I* : INT ;
	iMode AT %I* :BYTE;
END_VAR
